# Keil uVision project stm32g431_esc.uvprojx, settings and files
target STM32G431CBU6 (6220000::V6.22::ARMCLANG)
  device: STM32G431CBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: stm32g431_esc
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group inc
    ./: led.h cdefs.h driver.h driver_spwm.h debug.h pot.h timer.h curr_limit.h
  group src
    ./: main.c led.c driver.c driver_spwm.c debug.c pot.c timer.c curr_limit.c
  group Device
    ./RTE/Device/: startup_stm32g431xx.s system_stm32g4xx.c
software components: CMSIS:CORE 6.1.1
